# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rtthread-w60x
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: .\makeimg.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARM_LIBC, WM_W600
  c misc: --c99 --gnu
  c include: .;rt-thread\include;.;applications;drivers;func;libraries\smartconfig\inc;libraries\WM_Libraries;libraries\WM_Libraries\Include;libraries\WM_Libraries\Include\Driver;libraries\WM_Libraries\Platform\Drivers\spi;libraries\WM_Libraries\Include\OS;libraries\WM_Libraries\Include\Platform;libraries\WM_Libraries\Include\OS;libraries\WM_Libraries\Include\WiFi;libraries\WM_Libraries\Platform\Inc;libraries\WM_Libraries\Platform\Common\Params;libraries\WM_Libraries\Platform\Common\crypto;libraries\WM_Libraries\Platform\Common\crypto\digest;libraries\WM_Libraries\Platform\Common\crypto\math;libraries\WM_Libraries\Platform\Common\crypto\symmetric;libraries\WM_Libraries\Platform\Boot\gcc;packages\adbd-latest\inc;packages\adbd-latest\services;packages\agile_button-latest\inc;packages\agile_led-latest\inc;packages\cJSON-v1.0.2;packages\EasyFlash-v3.3.0\inc;ports\easyflash;packages\fal-v0.3.0\inc;ports\fal;packages\libmodbus-latest\examples;packages\libmodbus-latest\inc;packages\netutils-v1.1.0\ntp;packages\onenet-latest\inc;packages\pahomqtt-v1.1.0\MQTTPacket\src;packages\pahomqtt-v1.1.0\MQTTClient-RT;packages\tinycrypt-v1.0.0\include;packages\webclient-v2.1.1\inc;packages\webnet-latest\inc;ports\wifi;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\wlan;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\net\lwip-2.0.2\src;rt-thread\components\net\lwip-2.0.2\src\include;rt-thread\components\net\lwip-2.0.2\src\include\ipv4;rt-thread\components\net\lwip-2.0.2\src\arch\include;rt-thread\components\net\lwip-2.0.2\src\include\netif;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket
  memory RVCT4: ROM 0x8010100 size 0xefeff
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x20028000 size 0x14000
  scatter file: .\drivers\linker_scripts\link.sct
  link misc: --diag_suppress=L6314 --diag_suppress=L6329
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: cloud.c collect.c dcu.c key.c led.c main.c web.c
  group Drivers
    drivers/: board.c drv_uart.c drv_flash.c pin_map.c drv_wifi.c drv_pin.c drv_spi.c drv_spiflash.c drv_lcd.c
  group func
    func/: json_create.c wn_cgi.c wn_firm_upload.c zmq.c
  group smartconfig
    libraries/smartconfig/: smartconfig_demo.c
  group smartconfig
    libraries/smartconfig/libs/: libsmartconfig_keil.lib
  group Libraries
    libraries/WM_Libraries/Platform/Drivers/cpu/: wm_cpu.c
    libraries/WM_Libraries/Platform/Drivers/gpio/: wm_gpio.c wm_gpio_afsel.c
    libraries/WM_Libraries/Platform/Drivers/io/: wm_io.c
    libraries/WM_Libraries/Platform/Drivers/irq/: wm_irq.c
    libraries/WM_Libraries/Platform/Drivers/efuse/: wm_efuse.c
    libraries/WM_Libraries/Platform/Drivers/internalflash/: wm_internal_fls.c
    libraries/WM_Libraries/Platform/Drivers/spi/: wm_hostspi.c
    libraries/WM_Libraries/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    libraries/WM_Libraries/Platform/Drivers/dma/: wm_dma.c
    libraries/WM_Libraries/Platform/Drivers/timer/: wm_timer.c
    libraries/WM_Libraries/Platform/Drivers/watchdog/: wm_watchdog.c
    libraries/WM_Libraries/Platform/Drivers/i2c/: wm_i2c.c
    libraries/WM_Libraries/Platform/Drivers/pwm/: wm_pwm.c
    libraries/WM_Libraries/Platform/Drivers/adc/: wm_adc.c
    libraries/WM_Libraries/Platform/Drivers/pmu/: wm_pmu.c
    libraries/WM_Libraries/Platform/Drivers/rtc/: wm_rtc.c
    libraries/WM_Libraries/Platform/Common/Params/: wm_param.c
    libraries/WM_Libraries/Platform/Common/fwup/: wm_fwup.c
    libraries/WM_Libraries/Platform/Common/crypto/: wm_crypto_hard.c
    libraries/WM_Libraries/Platform/Common/crypto/digest/: wm_crypto_hmac.c wm_crypto_md2.c wm_crypto_md4.c sha224.c sha384.c wm_crypto_sha512.c
    libraries/WM_Libraries/Platform/Common/crypto/keyformat/: asn1.c wm_crypto_base64.c wm_crypto_x509.c
    libraries/WM_Libraries/Platform/Common/crypto/math/: pstm_mul_comba.c
    libraries/WM_Libraries/Platform/Common/crypto/prng/: prng.c yarrow.c
    libraries/WM_Libraries/Platform/Common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c wm_crypto_rsa.c
    libraries/WM_Libraries/Platform/Common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    libraries/WM_Libraries/rtthread/: rtthread_patch.c
    libraries/WM_Libraries/rtthread/utils/: utils.c
    libraries/WM_Libraries/rtthread/startup/armcc/: startup_venus.S
    libraries/WM_Libraries/Platform/Boot/armcc/: misc.c
  group Libraries
    libraries/WM_Libraries/Lib/Wlan/: libwlan_mdk.lib
  group adb
    packages/adbd-latest/core/: adb.c adb_pque.c adb_service.c adbusb.c transport.c transport_socket.c transport_usb.c
    packages/adbd-latest/services/: shell_service.c file_sync_service.c file_exmod.c file_sync_mod.c file_list_mod.c
  group agile_button
    packages/agile_button-latest/src/: agile_button.c
  group agile_led
    packages/agile_led-latest/src/: agile_led.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group EasyFlash
    packages/EasyFlash-v3.3.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-v0.3.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_port.c fal_flash_sfud_port.c
  group libmodbus
    packages/libmodbus-latest/src/: modbus.c modbus-data.c modbus-tcp.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
  group onenet
    packages/onenet-latest/src/: onenet_http.c onenet_mqtt.c
  group paho-mqtt
    packages/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-v1.1.0/MQTTClient-RT/: paho_mqtt_pipe.c
  group TinyCrypt
    packages/tinycrypt-v1.0.0/src/: tiny_aes.c tiny_base64.c tiny_md5.c tiny_sha1.c tiny_sha2.c
  group WebClient
    packages/webclient-v2.1.1/src/: webclient.c
  group WebNet
    packages/webnet-latest/src/: webnet.c wn_mimetype.c wn_request.c wn_session.c wn_utils.c wn_module.c
    packages/webnet-latest/module/: wn_module_cgi.c wn_module_upload.c
  group wifi
    ports/wifi/: wifi_config.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
